# Keil uVision project pro.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: pro
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32L10X_HD
  c include: ..\APP;..\Project;.\RTE\Device\STM32F103RE;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\EDP;..\Network;..\Network\wifi;..\BSP\usart;..\BSP\led;..\BSP\sys;..\Malloc;..\BSP\dht11;..\BSP\delay;..\BSP\tmr
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ../APP/: main.c stm32f10x_it.c remote.c device.c
  group BSP
    ../BSP/usart/: usart.c
    ../BSP/led/: led.c
    ../BSP/sys/: sys.c
    ../BSP/dht11/: dht11.c
    ../BSP/delay/: delay.c
    ../BSP/tmr/: timer.c
  group Network
    ../Network/wifi/: wifi_config.c wifi_function.c
  group EDP
    ../EDP/: cJSON.c EdpKit.c
  group UCOSII/CFG
    ../UCOSII/CONFIG/: os_cfg.h includes.h
  group UCOSII/SRC
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group UCOSII/PORT
    ../UCOSII/PORT/: os_cpu_c.c os_dbg.c os_cpu_a.asm
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
